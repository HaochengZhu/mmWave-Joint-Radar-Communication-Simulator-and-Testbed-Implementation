options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: jrc_comm_sim_v0
    output_language: python
  states: {}

blocks:
- name: N_ltf
  id: variable
  parameters:
    value: ofdm_config.N_ltf
  states: {}
- name: N_rx
  id: variable
  parameters:
    value: '1'
  states: {}
- name: N_tx
  id: variable
  parameters:
    value: ofdm_config.N_tx
  states: {}
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 4,0,1,1
    label: Channel Estimation Algorithm
    labels: '["LS",  "STA"]'
    num_opts: '0'
    options: '[0,  1]'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: chan_est_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est_data.csv"
  states: {}
- name: chan_est_file
  id: variable
  parameters:
    value: '"/home/hostpc-usrp/temp/chan_est.csv"'
  states: {state: disabled}
- name: chan_est_file
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est.csv"
  states: {}
- name: chan_est_ndp_file
  id: variable
  parameters:
    value: parrent_path+"/data/chan_est_ndp.csv"
  states: {}
- name: comm_log_file
  id: variable
  parameters:
    value: '"/home/hostpc-usrp/temp/comm_log.csv"'
  states: {state: disabled}
- name: comm_log_file
  id: variable
  parameters:
    value: parrent_path+"/data/comm_log.csv"
  states: {}
- name: corr_window_size
  id: variable
  parameters:
    value: int(fft_len/2)
  states: {}
- name: cp_len
  id: variable
  parameters:
    value: int(fft_len/4)
  states: {}
- name: distance
  id: variable
  parameters:
    value: '20'
  states: {state: disabled}
- name: distance
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Distance
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: ofdm_config.N_sc
  states: {}
- name: freq
  id: variable
  parameters:
    value: 4e9
  states: {}
- name: interp_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: mcs
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 3,0,1,1
    label: Modulation and Coding Scheme
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2","16QAM 3/4" , "ReadFile"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6] '
    orient: Qt.QHBoxLayout
    type: int
    value: '3'
    widget: radio_buttons
  states: {}
- name: mcs_ctrl_file
  id: variable
  parameters:
    value: parrent_path+"/data/mcs_ctrl.csv"
  states: {}
- name: mimo_tap1
  id: variable
  parameters:
    value: cmath.exp(1j*cmath.pi*np.sin(np.deg2rad(theta)))
  states: {}
- name: mimo_tap1_angle
  id: variable
  parameters:
    value: np.arcsin( np.angle(mimo_tap1) / cmath.pi  )*180/cmath.pi
  states: {}
- name: noise_figure_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: noise_var
  id: variable
  parameters:
    value: 4e-21*samp_rate*10**(noise_figure_dB/10.0)
  states: {}
- name: packet_data_file
  id: variable
  parameters:
    value: parrent_path+"/data/packet_data.csv"
  states: {}
- name: parrent_path
  id: variable
  parameters:
    value: '"/home/haocheng/O-JRC/examples"'
  states: {}
- name: path_loss
  id: variable
  parameters:
    value: 4*cmath.pi*distance/wavelength
  states: {}
- name: phased_steering
  id: variable_qtgui_chooser
  parameters:
    label: '''Phased Steering'''
    label0: 'OFF'
    label1: 'ON'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: radar_aided
  id: variable_qtgui_chooser
  parameters:
    label: Radar-aided Precoding
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: radar_log_file
  id: variable
  parameters:
    value: '"/home/hostpc-usrp/temp/radar_log.csv"'
  states: {state: disabled}
- name: radar_log_file
  id: variable
  parameters:
    value: parrent_path+"/data/radar_log.csv"
  states: {}
- name: radar_read_file
  id: variable
  parameters:
    value: parrent_path+"/data/radar_data.csv"
  states: {}
- name: record_comm_stats
  id: variable_qtgui_chooser
  parameters:
    label: Record Comm Stats
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: freq+20e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '150000000'
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: 4*(fft_len+cp_len)
  states: {}
- name: target_OFDM_symbols
  id: variable
  parameters:
    comment: |-
      fix OFDM symbols per packet.
      >0 enable，according to MCS to cut or adding 0;
      ==0 for fixed packet data payload length
    value: '16'
  states: {}
- name: theta
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Azimuth Angle
    orient: Qt.Horizontal
    start: '-90'
    step: '1'
    stop: '90'
    value: '20'
  states: {}
- name: tx_multiplier
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: TX Gain
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '0.50'
  states: {}
- name: use_radar_streams
  id: variable_qtgui_chooser
  parameters:
    label: Using Radar Streams
    label0: 'False'
    label1: 'True'
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: default
    option: key
    section: main
    type: real
    value: '0'
    writeback: None
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: 3e8/rf_freq
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(fft_len/4)
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: (2+N_ltf)*(fft_len+cp_len)
    max_iter: '4000'
    scale: 1/((2+N_ltf)*(fft_len+cp_len))
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    affinity: '[3,4]'
    length: int(1.5*corr_window_size)
    max_iter: '16000'
    scale: 1/1.5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_multiplier
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/path_loss
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: (1/path_loss)*cmath.exp(1j*cmath.pi*np.sin(np.deg2rad(theta)))
    const: (1/path_loss)*cmath.exp(1j*cmath.pi*np.sin(np.deg2rad(theta)))
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: (1/path_loss)*cmath.exp(1j*cmath.pi*np.sin(np.deg2rad(theta)))
    const: (1/path_loss)*cmath.exp(2j*cmath.pi*np.sin(np.deg2rad(theta)))
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: (1/path_loss)*cmath.exp(1j*cmath.pi*np.sin(np.deg2rad(theta)))
    const: (1/path_loss)*cmath.exp(3j*cmath.pi*np.sin(np.deg2rad(theta)))
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: len(ofdm_config.data_subcarriers)
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: len(ofdm_config.data_subcarriers)
  states: {state: disabled}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: len(ofdm_config.data_subcarriers)
  states: {state: disabled}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '5000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {state: disabled}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '5000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_1
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '5000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
    vlen: ofdm_config.N_data
  states: {state: disabled}
- name: blocks_tag_debug_0_1_0_0_0
  id: blocks_tag_debug
  parameters:
    name: MIMO PRECODER
    type: complex
    vlen: fft_len
  states: {state: disabled}
- name: blocks_tag_debug_0_1_0_0_0_0
  id: blocks_tag_debug
  parameters:
    name: CYCLIC
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0_1_0_0_0_1
  id: blocks_tag_debug
  parameters:
    name: Encoder
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(ofdm_config.data_subcarriers)
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    comment: |-
      CFO Detect = freq_offset * 2*PI

      1.8/fft_len
      1.5/fft_len
    epsilon: '1.0'
    freq_offset: 0.02/fft_len
    noise_voltage: np.sqrt(noise_var)
    seed: '0'
    taps: '[1.0]'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: cp_len
    input_size: fft_len
    tagname: '"packet_len"'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(fft_len)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: fft_vxx_0_2_0_0
  id: fft_vxx
  parameters:
    comment: tuple([1/52**.5] * 64)
    fft_size: fft_len
    forward: 'False'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: tuple([1/64**.5] * 64)
  states: {}
- name: helper_frame_detector_0
  id: helper_frame_detector
  parameters:
    cp_len: cp_len
    debug: 'False'
    fft_len: fft_len
    ignore_gap: (len(ofdm_config.l_stf_ltf_64)+N_tx)*(fft_len+cp_len)
    min_n_peaks: '10'
    threshold: '0.6'
  states: {state: disabled}
- name: helper_frame_sync_0
  id: helper_frame_sync
  parameters:
    cp_len: cp_len
    debug: 'False'
    fft_len: fft_len
    ltf_seq_time: ofdm_config.l_ltf_fir
    sync_length: sync_length
  states: {state: disabled}
- name: helper_gui_time_plot_0
  id: helper_gui_time_plot
  parameters:
    interval: '250'
    label: '"Signal-to-Noise Ratio"'
    time_window: '10'
    y_axis_lim: '[0, 40]'
    y_label: '"SNR [dB]"'
    y_tag: '"snr"'
  states: {state: disabled}
- name: helper_gui_time_plot_1
  id: helper_gui_time_plot
  parameters:
    interval: '250'
    label: '"Packet Error Rate"'
    time_window: '10'
    y_axis_lim: '[0, 102]'
    y_label: '"PER [%]"'
    y_tag: '"per"'
  states: {state: disabled}
- name: helper_mimo_ofdm_equalizer_0
  id: helper_mimo_ofdm_equalizer
  parameters:
    bw: samp_rate
    chan_est_file: chan_est_file
    comm_log_file: '""'
    cp_len: cp_len
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    estimator: chan_est
    fft_len: fft_len
    freq: rf_freq
    long_seq: ofdm_config.l_stf_ltf_64[3]
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    minoutbuf: '80000'
    n_mimo_ltf: N_tx
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    stats_record: 'False'
  states: {state: disabled}
- name: helper_mimo_precoder_0
  id: helper_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    chan_est_file: chan_est_file
    chan_est_smoothing: 'False'
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    phased_steering: phased_steering
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    radar_aided: radar_aided
    radar_log_file: radar_log_file
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: use_radar_streams
  states: {state: disabled}
- name: helper_moving_avg_0
  id: helper_moving_avg
  parameters:
    debug: 'False'
    length: corr_window_size
    max_iter: '16000'
    scale: '1'
  states: {state: disabled}
- name: helper_stream_decoder_0
  id: helper_stream_decoder
  parameters:
    debug: 'False'
    n_data_carriers: len(ofdm_config.data_subcarriers)
    stats_path: comm_log_file
    stats_record: record_comm_stats
  states: {state: disabled}
- name: helper_zero_pad_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {state: disabled}
- name: helper_zero_pad_0_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {state: disabled}
- name: helper_zero_pad_0_1
  id: helper_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {state: disabled}
- name: helper_zero_pad_0_1_0
  id: helper_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import string
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: interp_fir_filter_xxx_0_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: ofdm_config.l_ltf_fir
    type: ccc
  states: {state: disabled}
- name: mimo_ofdm_jrc_Stream_decoder_DynModulation_0
  id: mimo_ofdm_jrc_Stream_decoder_DynModulation
  parameters:
    affinity: '[5]'
    debug: 'False'
    n_data_carriers: len(ofdm_config.data_subcarriers)
    stats_path: comm_log_file
    stats_record: record_comm_stats
  states: {state: disabled}
- name: mimo_ofdm_jrc_comm_target_simulator_0
  id: mimo_ofdm_jrc_comm_target_simulator
  parameters:
    center_freq_hz: 24e9
    distance_m: distance
    min_distance_m: '0.01'
    num_tx: '4'
    theta_deg: theta
    use_two_pi: 'False'
  states: {}
- name: mimo_ofdm_jrc_frame_detector_0
  id: mimo_ofdm_jrc_frame_detector
  parameters:
    cp_len: cp_len
    debug: 'False'
    fft_len: fft_len
    ignore_gap: (len(ofdm_config.l_stf_ltf_64)+N_tx)*(fft_len+cp_len)
    min_n_peaks: '10'
    threshold: '0.6'
  states: {}
- name: mimo_ofdm_jrc_frame_sync_0
  id: mimo_ofdm_jrc_frame_sync
  parameters:
    cp_len: cp_len
    debug: 'False'
    fft_len: fft_len
    ltf_seq_time: ofdm_config.l_ltf_fir
    sync_length: sync_length
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_0
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Signal-to-Noise Ratio"'
    time_window: '10'
    y_axis_lim: '[0,40]'
    y_label: '"SNR [dB]"'
    y_tag: '"snr"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_1
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Packet Error Rate"'
    time_window: '10'
    y_axis_lim: '[0,102]'
    y_label: '"PER [%]"'
    y_tag: '"per"'
  states: {}
- name: mimo_ofdm_jrc_gui_time_plot_1_0
  id: mimo_ofdm_jrc_gui_time_plot
  parameters:
    interval: '250'
    label: '"Received Data Throughput"'
    time_window: '10'
    y_axis_lim: '[0,5]'
    y_label: '"Throughput [KByte/s]"'
    y_tag: '"throughput"'
  states: {state: disabled}
- name: mimo_ofdm_jrc_mimo_ofdm_equalizer_0
  id: mimo_ofdm_jrc_mimo_ofdm_equalizer
  parameters:
    bw: samp_rate
    chan_est_data_file: chan_est_data_file
    chan_est_file: chan_est_file
    chan_est_ndp_file: chan_est_ndp_file
    comm_log_file: comm_log_file
    cp_len: cp_len
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    estimator: chan_est
    fft_len: fft_len
    freq: rf_freq
    long_seq: ofdm_config.l_stf_ltf_64[3]
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    minoutbuf: '80000'
    n_mimo_ltf: N_tx
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    stats_record: 'False'
  states: {}
- name: mimo_ofdm_jrc_mimo_precoder_0
  id: mimo_ofdm_jrc_mimo_precoder
  parameters:
    N_ss: '1'
    N_tx: N_tx
    chan_est_file: chan_est_file
    chan_est_smoothing: 'False'
    data_carriers: ofdm_config.data_subcarriers
    debug: 'False'
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    mapped_ltf_symbols: ofdm_config.ltf_mapped_sc__ss_sym
    phased_steering: phased_steering
    pilot_carriers: ofdm_config.pilot_subcarriers
    pilot_symbols: ofdm_config.pilot_symbols
    radar_aided: radar_aided
    radar_log_file: radar_read_file
    sync_words: ofdm_config.l_stf_ltf_64
    use_radar_streams: use_radar_streams
  states: {}
- name: mimo_ofdm_jrc_moving_avg_0
  id: mimo_ofdm_jrc_moving_avg
  parameters:
    debug: 'False'
    length: corr_window_size
    max_iter: '16000'
    scale: '1'
  states: {}
- name: mimo_ofdm_jrc_ndp_generator_0
  id: mimo_ofdm_jrc_ndp_generator
  parameters: {}
  states: {}
- name: mimo_ofdm_jrc_packet_switch_0
  id: mimo_ofdm_jrc_packet_switch
  parameters:
    packet_info_file: packet_data_file
    period_ms: '50'
  states: {}
- name: mimo_ofdm_jrc_socket_pdu_jrc_0
  id: mimo_ofdm_jrc_socket_pdu_jrc
  parameters:
    MTU: '10000'
    host: ''
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: mimo_ofdm_jrc_stream_decoder_0
  id: mimo_ofdm_jrc_stream_decoder
  parameters:
    debug: 'False'
    n_data_carriers: len(ofdm_config.data_subcarriers)
    stats_path: comm_log_file
    stats_record: record_comm_stats
  states: {}
- name: mimo_ofdm_jrc_stream_encoder_0
  id: mimo_ofdm_jrc_stream_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mod_encode: mcs
  states: {state: disabled}
- name: mimo_ofdm_jrc_stream_encoder_1
  id: mimo_ofdm_jrc_stream_encoder
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mod_encode: mcs
  states: {}
- name: mimo_ofdm_jrc_stream_encoder_automodulation_0
  id: mimo_ofdm_jrc_stream_encoder_automodulation
  parameters:
    N_ss_radar: '0'
    data_len: ofdm_config.N_data
    debug: 'False'
    mcs_ctrl_file: mcs_ctrl_file
    mod_encode: mcs
    target_nsym: target_OFDM_symbols
  states: {state: disabled}
- name: mimo_ofdm_jrc_zero_pad_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {}
- name: mimo_ofdm_jrc_zero_pad_0_0_0_0
  id: mimo_ofdm_jrc_zero_pad
  parameters:
    debug: 'False'
    pad_front: '5'
    pad_tail: 6*(fft_len+cp_len)+10
  states: {}
- name: ofdm_config
  id: epy_module
  parameters:
    source_code: |
      # %% this module will be imported in the into your flowgraph
      import numpy as np
      # import matplotlib.pyplot as plt

      N_tx = 4
      N_ltf = N_tx
      N_sc = 64

      data_subcarriers = list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) +list( range(22, 27))
      pilot_subcarriers = [-21, -7, 7, 21]
      pilot_symbols = ((1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (1, 1, 1, -1), (1, 1, 1, -1), (1, 1, 1, -1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1), (-1, -1, -1, 1))

      N_data = len(data_subcarriers)
      N_pilot = len(pilot_subcarriers)

      # l_stf_ltf_128_custom = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (-1.4719601443879744-1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, (1.4719601443879744+1.4719601443879744j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, (-0-1j), (-0-1j), -1j, -1j, 1j, (-0-1j), -1j, 1j, 1j, (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), (-0-1j), 1j, 1j, 1j, 1j, 1j, -1j, 1j, (-0-1j), 1j, -1j, (-0-1j), 1j, 1j, -1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), 1j, -1j, 1j, (-0-1j), (-0-1j), 1j, 1j, (-0-1j), (-0-1j), -1j, -1j, (-0-1j), (-0-1j), 1j, -1j, 1j, (-0-1j), 1j, 1j, (-0-1j), 1j, 0, (-1-0j), -1, (-1+0j), 1, (1+0j), 1, (-1+0j), -1, (1+0j), 1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), 1, (1+0j), -1, (-1+0j), 1, (1+0j), 1, (1+0j), 1, (-1-0j), 1, (-1+0j), 1, (-1-0j), -1, (1+0j), 1, (-1-0j), -1, (-1+0j), -1, (-1-0j), -1, (1+0j), -1, (1+0j), -1, (-1+0j), 1, (1+0j), -1, (-1+0j), -1, (-1-0j), -1, (-1+0j), 1, (-1-0j), 1, (-1+0j), -1, (-1-0j), -1, 0j), 
      #     (0, 0, 1j, -1, -1j, 1, -1j, -1, -1j, -1, -1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, -1, 1j, 1, -1j, -1, 1j, -1, 1j, 1, 0, -1j, 1, 1j, 1, 1j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, -1j, 1, -1j, 1, -1j, 1, 1j, -1, -1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, -1, -1j, 1, 0))

      # l_stf_ltf_64 = ((0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0),
      #  (0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0), 
      #     (0, 0j, 0, 0j, 0, 0j, -1, 1j, -1, 1j, -1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, (-0-1j), 1, -1j, -1, 1j, 0, -1j, 1, (-0-1j), 1, -1j, 1, 1j, -1, -1j, 1, (-0-1j), -1, 1j, 1, 1j, 1, 1j, 1, 1j, -1, -1j, 1, 1j, 1, -1j, -1, 0j, 0, 0j, 0, 0j), 
      #     (0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0))


      l_stf_64_def = np.array([0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (-1.4719601443879746-1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, (1.4719601443879746+1.4719601443879746j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0])
      l_ltf_64_def = np.array([0, 0, 0, 0, 0, 0, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 0, 0, 0, 0])


      l_ltf_64_custom = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0])

      assert(len(l_stf_64_def) == N_sc)
      assert(len(l_ltf_64_def) == N_sc)
      assert(len(l_ltf_64_custom) == N_sc)


      symbol_rotation = np.array([1, -1j, -1, 1j] * 16)
      l_ltf_64_rot = symbol_rotation*l_ltf_64_custom
      l_stf_ltf_64 = np.vstack((l_stf_64_def, l_stf_64_def, l_ltf_64_rot, l_ltf_64_custom))

      # MATLAB
      # [ltfLeft, ltfRight] = wlan.internal.lltfSequence()
      # [zeros(4,1); 1; 1; ltfLeft; 0; ltfRight;-1;-1; zeros(3,1)];
      ltf_64 = np.array([0, 0, 0, 0, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 1, 1, -1, -1, 1, 1, -1, 1, -1, 1, 1, 1, 1, 0, 1, -1, -1, 1, 1, -1, 1, -1, 1, -1, -1, -1, -1, -1, 1, 1, -1, -1, 1, -1, 1, -1, 1, 1, 1, 1, -1, -1, 0, 0, 0], dtype=np.complex64)
      P_ltf = np.array([[1, -1, 1, 1], [1, 1, -1, 1], [1, 1, 1, -1], [-1, 1, 1, 1]], dtype=np.complex64)


      ltf_tx = []
      for i_tx in range(N_tx):
          ltf_tx.append(tuple(map(tuple, np.outer(P_ltf[i_tx,:N_ltf],ltf_64))))


      ltf_mapped_64 = []
      for i_tx in range(N_tx):
          ltf_expand_time = np.outer(P_ltf[i_tx,:N_ltf], ltf_64)
          ltf_mapped_64.append(ltf_expand_time.flatten().tolist())

      # ltf_mapped_64 = np.array(ltf_mapped_64).T
      ltf_mapped_64 = np.array(ltf_mapped_64)


      # Nsc X (Ntx.Nltf) [ second dimension is row-major of (Ntx X Nltf) ]
      ltf_mapped_sc__ss_sym = []
      for i_sc in range(N_sc):
          ltf_ss_sym = P_ltf[:N_tx,:N_ltf]*ltf_64[i_sc]
          ltf_mapped_sc__ss_sym.append(ltf_ss_sym.flatten().tolist()) # --> flatten() follows row-major order

      ltf_mapped_sc__ss_sym = np.array(ltf_mapped_sc__ss_sym)

      # %%
      l_ltf = l_stf_ltf_64[3]
      l_ltf_time = N_sc*np.fft.ifft(np.fft.fftshift(l_ltf)) / np.sqrt(np.count_nonzero(l_ltf))
      l_ltf_fir = np.conj(l_ltf_time)
      l_ltf_fir = l_ltf_fir[::-1]

      # plt.figure()
      # plt.plot(np.abs(l_ltf_time))

      # plt.figure()
      # plt.plot(np.abs(np.convolve(l_ltf_fir,l_ltf_time,'full')))

      # %%
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.6'
    grid: 'True'
    gui_hint: 5,0,1,1
    name: CONSTELLATIONS
    size: ofdm_config.N_data*5
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"stream_start"'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    alpha1: '0.7'
    bins: '100'
    color1: '"dark blue"'
    grid: 'True'
    legend: 'False'
    size: '100'
    type: float
    xmax: '100'
    xmin: '0'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,1,1
    label1: Power
    name: TX1 Power
    type: float
    unit1: dBm
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"FRAME SYNC"'
    size: (fft_len+cp_len)*30
    srate: '1'
    tr_delay: '100'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    name: '"FRAME SYNC CORR"'
    size: sync_length*2
    srate: '1'
    tr_delay: '100'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: float
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.7'
    alpha2: '0.7'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 6,0,1,1
    label1: ''
    label2: ''
    name: Signal TX1
    size: (fft_len+cp_len)*40
    srate: '1'
    tr_delay: '50'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    width1: '2'
    width2: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: Signal SENT FFT
    size: fft_len*8
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: PRECODER 1
    size: fft_len*13
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    name: PRECODER 2
    size: fft_len*13
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: FFT RX
    size: fft_len*12
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: EQ OUT
    size: ofdm_config.N_data*10
    srate: '1'
    tr_delay: '10'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"stream_start"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 5,0,1,1
    label1: ''
    label2: ''
    name: Signal RX
    size: (fft_len+cp_len)*15
    srate: '1'
    tr_delay: '100'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"packet_len"'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    grid: 'True'
    gui_hint: 8,0,1,1
    label1: ''
    name: '"PREAMBLE DETECTOR"'
    size: (fft_len+cp_len)*30
    srate: '1'
    tr_delay: '300'
    tr_level: '0.65'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: ''
    type: float
    update_time: '0.1'
    width1: '2'
    ymax: '2'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.6'
    alpha2: '0.6'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 7,0,1,1
    label1: ''
    label2: ''
    name: '"FRAME"'
    size: (fft_len+cp_len)*20
    srate: '1'
    tr_delay: '300'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
    width1: '2'
    width2: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.8'
    autoscale: 'True'
    color1: dark blue
    entags: 'False'
    grid: 'True'
    legend: 'False'
    marker1: '0'
    size: '100'
    srate: '1'
    type: float
    update_time: '0.010'
    width1: '2'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: RX
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: FRAME
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: TX4
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: FRAME
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: TX1
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX2
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX3
  states: {}
- name: virtual_source_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: TX4
  states: {}

connections:
- [blocks_abs_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_add_xx_0_0, '0', channels_channel_model_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', helper_frame_sync_0, '0']
- [blocks_delay_0, '0', mimo_ofdm_jrc_frame_sync_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', helper_frame_detector_0, '0']
- [blocks_delay_0_0, '0', mimo_ofdm_jrc_frame_detector_0, '0']
- [blocks_divide_xx_0, '0', helper_frame_detector_0, '1']
- [blocks_divide_xx_0, '0', mimo_ofdm_jrc_frame_detector_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_abs_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_0, '0', helper_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', mimo_ofdm_jrc_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', helper_zero_pad_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', helper_zero_pad_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', helper_zero_pad_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', mimo_ofdm_jrc_zero_pad_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_add_xx_0_0, '2']
- [blocks_multiply_const_vxx_1_0_0_0, '0', blocks_add_xx_0_0, '3']
- [blocks_multiply_xx_0, '0', helper_moving_avg_0, '0']
- [blocks_multiply_xx_0, '0', mimo_ofdm_jrc_moving_avg_0, '0']
- [blocks_nlog10_ff_1, '0', qtgui_number_sink_0, '0']
- [blocks_socket_pdu_0, pdus, mimo_ofdm_jrc_stream_encoder_1, pdu_in]
- [blocks_socket_pdu_0, pdus, mimo_ofdm_jrc_stream_encoder_automodulation_0, pdu_in]
- [blocks_socket_pdu_0_0, pdus, mimo_ofdm_jrc_comm_target_simulator_0, cfg]
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0_0_1_1, '0']
- [blocks_throttle_0, '0', virtual_sink_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0_1, '0']
- [blocks_vector_to_stream_0_0_0, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [blocks_vector_to_stream_0_0_0_0, '0', qtgui_time_sink_x_0_0_1_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_1_0_0_0, '0']
- [blocks_vector_to_stream_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_1_0_0_0_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', blocks_tag_debug_0_1_0_0_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', virtual_sink_0_1, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0, '0', virtual_sink_0_1_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0_0_0, '0', virtual_sink_0_1_0_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', blocks_null_sink_0_3, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0_0_0_0_0, '0']
- [fft_vxx_0_0, '0', helper_mimo_ofdm_equalizer_0, '0']
- [fft_vxx_0_0, '0', mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0']
- [fft_vxx_0_2, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_2_0, '0', digital_ofdm_cyclic_prefixer_0_0_0, '0']
- [fft_vxx_0_2_0_0, '0', digital_ofdm_cyclic_prefixer_0_0_0_0, '0']
- [helper_frame_detector_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [helper_frame_detector_0, '0', virtual_sink_0_0_0, '0']
- [helper_frame_sync_0, '0', blocks_stream_to_vector_0, '0']
- [helper_frame_sync_0, '0', qtgui_time_sink_x_0, '0']
- [helper_mimo_ofdm_equalizer_0, '0', blocks_null_sink_0, '0']
- [helper_mimo_ofdm_equalizer_0, '0', blocks_tag_debug_0, '0']
- [helper_mimo_ofdm_equalizer_0, '0', blocks_vector_to_stream_0, '0']
- [helper_mimo_ofdm_equalizer_0, '0', helper_stream_decoder_0, '0']
- [helper_mimo_precoder_0, '0', blocks_vector_to_stream_0_0_0_0, '0']
- [helper_mimo_precoder_0, '0', fft_vxx_0, '0']
- [helper_mimo_precoder_0, '1', blocks_vector_to_stream_0_0_0_0_0, '0']
- [helper_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [helper_mimo_precoder_0, '2', fft_vxx_0_2_0, '0']
- [helper_mimo_precoder_0, '3', fft_vxx_0_2_0_0, '0']
- [helper_moving_avg_0, '0', blocks_complex_to_mag_0, '0']
- [helper_moving_avg_0, '0', helper_frame_detector_0, '2']
- [helper_stream_decoder_0, '0', blocks_null_sink_0_0, '0']
- [helper_stream_decoder_0, '0', qtgui_histogram_sink_x_0, '0']
- [helper_stream_decoder_0, '0', qtgui_time_sink_x_1, '0']
- [helper_stream_decoder_0, stats, helper_gui_time_plot_0, stats]
- [helper_stream_decoder_0, stats, helper_gui_time_plot_1, stats]
- [helper_stream_decoder_0, sym, blocks_socket_pdu_1, pdus]
- [helper_zero_pad_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [helper_zero_pad_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [helper_zero_pad_0_1, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [helper_zero_pad_0_1_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [mimo_ofdm_jrc_Stream_decoder_DynModulation_0, '0', blocks_null_sink_0_0, '0']
- [mimo_ofdm_jrc_Stream_decoder_DynModulation_0, stats, mimo_ofdm_jrc_gui_time_plot_0, stats]
- [mimo_ofdm_jrc_Stream_decoder_DynModulation_0, stats, mimo_ofdm_jrc_gui_time_plot_1, stats]
- [mimo_ofdm_jrc_Stream_decoder_DynModulation_0, stats, mimo_ofdm_jrc_gui_time_plot_1_0, stats]
- [mimo_ofdm_jrc_Stream_decoder_DynModulation_0, sym, blocks_socket_pdu_1, pdus]
- [mimo_ofdm_jrc_comm_target_simulator_0, '0', channels_channel_model_0, '0']
- [mimo_ofdm_jrc_frame_detector_0, '0', qtgui_time_sink_x_0_2_0, '0']
- [mimo_ofdm_jrc_frame_detector_0, '0', virtual_sink_0_0_0, '0']
- [mimo_ofdm_jrc_frame_sync_0, '0', blocks_stream_to_vector_0, '0']
- [mimo_ofdm_jrc_frame_sync_0, '0', qtgui_time_sink_x_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0', blocks_null_sink_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0', blocks_vector_to_stream_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0', helper_stream_decoder_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0', mimo_ofdm_jrc_Stream_decoder_DynModulation_0, '0']
- [mimo_ofdm_jrc_mimo_ofdm_equalizer_0, '0', mimo_ofdm_jrc_stream_decoder_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '0', fft_vxx_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '1', fft_vxx_0_2, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '2', fft_vxx_0_2_0, '0']
- [mimo_ofdm_jrc_mimo_precoder_0, '3', fft_vxx_0_2_0_0, '0']
- [mimo_ofdm_jrc_moving_avg_0, '0', blocks_complex_to_mag_0, '0']
- [mimo_ofdm_jrc_moving_avg_0, '0', helper_frame_detector_0, '2']
- [mimo_ofdm_jrc_moving_avg_0, '0', mimo_ofdm_jrc_frame_detector_0, '1']
- [mimo_ofdm_jrc_ndp_generator_0, out, mimo_ofdm_jrc_stream_encoder_1, pdu_in]
- [mimo_ofdm_jrc_ndp_generator_0, out, mimo_ofdm_jrc_stream_encoder_automodulation_0, pdu_in]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_ndp_generator_0, enable]
- [mimo_ofdm_jrc_packet_switch_0, strobe, mimo_ofdm_jrc_socket_pdu_jrc_0, enable]
- [mimo_ofdm_jrc_socket_pdu_jrc_0, pdus, mimo_ofdm_jrc_stream_encoder_1, pdu_in]
- [mimo_ofdm_jrc_socket_pdu_jrc_0, pdus, mimo_ofdm_jrc_stream_encoder_automodulation_0, pdu_in]
- [mimo_ofdm_jrc_stream_decoder_0, '0', blocks_null_sink_0_0, '0']
- [mimo_ofdm_jrc_stream_decoder_0, stats, helper_gui_time_plot_0, stats]
- [mimo_ofdm_jrc_stream_decoder_0, stats, helper_gui_time_plot_1, stats]
- [mimo_ofdm_jrc_stream_decoder_0, stats, mimo_ofdm_jrc_gui_time_plot_0, stats]
- [mimo_ofdm_jrc_stream_decoder_0, stats, mimo_ofdm_jrc_gui_time_plot_1, stats]
- [mimo_ofdm_jrc_stream_decoder_0, stats, mimo_ofdm_jrc_gui_time_plot_1_0, stats]
- [mimo_ofdm_jrc_stream_decoder_0, sym, blocks_socket_pdu_1, pdus]
- [mimo_ofdm_jrc_stream_encoder_0, '0', helper_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_stream_encoder_1, '0', helper_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_stream_encoder_1, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_stream_encoder_automodulation_0, '0', mimo_ofdm_jrc_mimo_precoder_0, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', blocks_multiply_const_vxx_1, '0']
- [mimo_ofdm_jrc_zero_pad_0, '0', mimo_ofdm_jrc_comm_target_simulator_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0, '0', mimo_ofdm_jrc_comm_target_simulator_0, '1']
- [mimo_ofdm_jrc_zero_pad_0_0_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0_0, '0', mimo_ofdm_jrc_comm_target_simulator_0, '2']
- [mimo_ofdm_jrc_zero_pad_0_0_0_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [mimo_ofdm_jrc_zero_pad_0_0_0_0, '0', mimo_ofdm_jrc_comm_target_simulator_0, '3']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0_0, '0', blocks_delay_0, '0']
- [virtual_source_0_0, '0', helper_frame_sync_0, '1']
- [virtual_source_0_0, '0', mimo_ofdm_jrc_frame_sync_0, '0']
- [virtual_source_0_1_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_1_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [virtual_source_0_1_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [virtual_source_0_1_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']

metadata:
  file_format: 1
